# Keil uVision project Application.uvprojx, settings and files
target Application (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Application +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__TARGET_FPU_VFP,__FPU_PRESENT,ARM_MATH_CM4
  c include: ..\Library\SysLib\Standard\Configuration;..\Library\SysLib\Standard\Peripheral\inc;..\Library\SysLib\ArmMathLib\inc;..\Library\ExtLib;..\Library\ExtLib\IQMathLib\inc;..\Library\ExtLib\Ymodem\inc;..\Library\ExtLib\LittleVGL;..\System\FreeRTOS\Core\inc;..\System\FreeRTOS\Ports\RVDS\ARM_CM4F;..\Users\Drives\inc;..\Users\Control\Main\inc;..\Users\Control\Gui\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ../Library/SysLib/Standard/Startup/: startup_stm32f40_41xxx.s
    ../Library/SysLib/Standard/Configuration/: system_stm32f4xx.c
  group ExtLib
    ../Library/ExtLib/IQMathLib/src/: IQmathLib.lib
    ../Library/ExtLib/Ymodem/src/: Ymodem.c
  group SysLib
    ../Library/SysLib/ArmMathLib/src/: arm_cortexM4lf_math.lib
    ../Library/SysLib/Standard/Peripheral/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_it.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS_Core
    ../System/FreeRTOS/Core/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../System/FreeRTOS/Core/inc/: FreeRTOSConfig.h
  group FreeRTOS_Port
    ../System/FreeRTOS/Ports/RVDS/ARM_CM4F/: port.c
    ../System/FreeRTOS/Ports/MemMang/: heap_4.c
  group LittleVGL_Core
    ../Library/ExtLib/LittleVGL/: lv_conf.h
    ../Library/ExtLib/LittleVGL/core/: lv_port_disp.c lv_port_indev.c lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Library/ExtLib/LittleVGL/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Library/ExtLib/LittleVGL/extra/: lv_extra.c
    ../Library/ExtLib/LittleVGL/extra/widgets/animimg/: lv_animimg.c
    ../Library/ExtLib/LittleVGL/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Library/ExtLib/LittleVGL/extra/widgets/chart/: lv_chart.c
    ../Library/ExtLib/LittleVGL/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Library/ExtLib/LittleVGL/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Library/ExtLib/LittleVGL/extra/widgets/keyboard/: lv_keyboard.c
    ../Library/ExtLib/LittleVGL/extra/widgets/led/: lv_led.c
    ../Library/ExtLib/LittleVGL/extra/widgets/list/: lv_list.c
    ../Library/ExtLib/LittleVGL/extra/widgets/meter/: lv_meter.c
    ../Library/ExtLib/LittleVGL/extra/widgets/msgbox/: lv_msgbox.c
    ../Library/ExtLib/LittleVGL/extra/widgets/span/: lv_span.c
    ../Library/ExtLib/LittleVGL/extra/widgets/spinbox/: lv_spinbox.c
    ../Library/ExtLib/LittleVGL/extra/widgets/spinner/: lv_spinner.c
    ../Library/ExtLib/LittleVGL/extra/widgets/tabview/: lv_tabview.c
    ../Library/ExtLib/LittleVGL/extra/widgets/tileview/: lv_tileview.c
    ../Library/ExtLib/LittleVGL/extra/widgets/win/: lv_win.c
    ../Library/ExtLib/LittleVGL/extra/themes/basic/: lv_theme_basic.c
    ../Library/ExtLib/LittleVGL/extra/themes/default/: lv_theme_default.c
    ../Library/ExtLib/LittleVGL/extra/themes/mono/: lv_theme_mono.c
    ../Library/ExtLib/LittleVGL/extra/others/snapshot/: lv_snapshot.c
    ../Library/ExtLib/LittleVGL/extra/libs/bmp/: lv_bmp.c
    ../Library/ExtLib/LittleVGL/extra/libs/freetype/: lv_freetype.c
    ../Library/ExtLib/LittleVGL/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Library/ExtLib/LittleVGL/extra/libs/gif/: gifdec.c lv_gif.c
    ../Library/ExtLib/LittleVGL/extra/libs/png/: lodepng.c lv_png.c
    ../Library/ExtLib/LittleVGL/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Library/ExtLib/LittleVGL/extra/libs/rlottie/: lv_rlottie.c
    ../Library/ExtLib/LittleVGL/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Library/ExtLib/LittleVGL/extra/layouts/flex/: lv_flex.c
    ../Library/ExtLib/LittleVGL/extra/layouts/grid/: lv_grid.c
    ../Library/ExtLib/LittleVGL/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Library/ExtLib/LittleVGL/gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_sdl.c lv_gpu_stm32_dma2d.c
    ../Library/ExtLib/LittleVGL/gpu/sdl/: lv_gpu_sdl_draw_arc.c lv_gpu_sdl_draw_blend.c lv_gpu_sdl_draw_img.c lv_gpu_sdl_draw_label.c lv_gpu_sdl_draw_line.c lv_gpu_sdl_draw_rect.c lv_gpu_sdl_lru.c lv_gpu_sdl_mask.c lv_gpu_sdl_stack_blur.c lv_gpu_sdl_texture_cache.c lv_gpu_sdl_utils.c
    ../Library/ExtLib/LittleVGL/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Library/ExtLib/LittleVGL/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Library/ExtLib/LittleVGL/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LittleVGL_App
    ../Users/Control/Gui/src/: tftlcd.c tftlcd_conf.c lv_example_win_1.c ILI9341.c rgb.c xpt2046.c
    ../Users/Control/Gui/inc/: xpt2046.h
  group Drives
    ../Users/Drives/src/: usart.c nvic.c led.c delay.c fsmc.c timer.c system.c at24c02.c i2c.c
    ../Users/Drives/inc/: timer.h
  group Control
    ../Users/Control/Main/src/: main.c start.c
software components: CMSIS:CORE 5.5.0
